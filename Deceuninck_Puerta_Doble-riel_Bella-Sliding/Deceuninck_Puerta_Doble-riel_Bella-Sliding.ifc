Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-14T13:36:09
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 14 13:36:09 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\cf07efaf-b963-45d9-bf45-b97a93fbf848\8f6ae4bd-6997-4456-9259-01eb9a02d9bf\ifc * Database version: 5507 * Database creation date: Thu Dec 14 13:36:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 14 13:36:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 14 13:36:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Puerta_Doble-riel_Bella-Sliding:Double rail Door, Deceuninck_Puerta_Doble-riel_Bella-Sliding:Double rail Door:519298
In: Level 1
Type - Classification: B2030100 Glazed Doors & Entrances (Uniformat); Material: Aluminium, PVC, Deceuninck - 1.Blanco/PVC, Galvanized steel, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Function: Interior; Wall Closure: By host
Type - Dimensions - Construction Height: 1905 mm; Construction Width: 2405 mm; Glass Height: 1718 mm; Glass Width: 2287 mm; Height: 1900 mm; Max. Height: 2900 mm; Max. Width: 2400 mm; Offset: 65 mm; Width: 2400 mm
Type - Identity Data - Assembly Code: B2030100; Assembly Description: Glazed Doors & Entrances; Constructive depth: 60mm; C-Section Model: https://skfb.ly/oOw8L; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 a 20mm; International Certification: ISO 9001-ISO 14001-BS OHSAS 18001 approved by TUV Rheiland; Line: Bella Sliding; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Double rail Door; OmniClass Number: 23.30.10.00; OmniClass Title: Doors; Opening: Sliding; Panels: 2 sliders; Rail Type: Double; Technical Area: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 64; Type Name: Double rail Door; URL: www.deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Bella-Corredera-DobleRiel-Puerta.pdf; Frame: Deceuninck - 1.Blanco/PVC; Handle: PVC; Rail: Aluminium; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.Blanco/PVC
Type - Model Properties - Acoustic insulation: Rw=29 (-1;-2) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 3 according to EN 12207; Fire rating: Class C-s3, d2 according to EN 13501-1; Water tightness: Class 6A according to EN 12208; Wind load resistance: Class C3/B4 according to EN 12210
Type - Other - Category: Doors; Family Name: Deceuninck_Puerta_Doble-riel_Bella-Sliding
Material: Glass, Deceuninck - 1.Blanco/PVC
Constraints - Level: Level: Level 1; Sill Height: 0 mm
Dimensions - Area: 10.7061 m2; Volume: 0.0677785 m3
Graphics - ON_OFF - High Inertia Profile: no
Identity Data - Mark: 42
Other - Family: Deceuninck_Puerta_Doble-riel_Bella-Sliding: Double rail Door; Family and Type: Deceuninck_Puerta_Doble-riel_Bella-Sliding: Double rail Door; Head Height: 1900 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Puerta_Doble-riel_Bella-Sliding: Double rail Door; Type Id: Deceuninck_Puerta_Doble-riel_Bella-Sliding: Double rail Door
Phasing - Phase Created: New Construction
